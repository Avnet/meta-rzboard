DESCRIPTION = "Remove VSP Manager for the RZG2 in meta-rzv"
LICENSE = "CLOSED"
