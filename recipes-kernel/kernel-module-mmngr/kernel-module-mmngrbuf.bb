DESCRIPTION = "Remove Memory Manager Buffer Kernel module for Renesas RZG2 in meta-rzv"
LICENSE = "CLOSED"
