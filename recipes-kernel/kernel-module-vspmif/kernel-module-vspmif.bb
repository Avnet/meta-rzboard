DESCRIPTION = "Remove VSP Manager Interface driver for the RZG2 in meta-rzv"
LICENSE = "CLOSED"
