# Revision for qt5.6.3

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
    file://0001-fix-true-false-textbreakiterator.patch \
"
