DESCRIPTION = "Remove Memory Manager Buffer User module for Renesas RZG2 in meta-rzv"
LICENSE = "CLOSED"
